Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-17T20:37:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 17 20:37:30 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{5221081D-1B63-42AC-95A6-451CD27BA83F}\ifc * Database version: 5507 * Database creation date: Wed Apr 17 20:37:29 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 17 20:37:30 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 17 20:37:30 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 23764034_D_11106610_DGM7640_GRGR, 11106610_D_DGM7640_GRGR:23764034_D_11106610_DGM7640_GRGR:205683
In: Level 1
Type - Classification: DGM7000 (Uniformat); Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR
Pset_BuildingElementProxyCommon - Reference: 23764034_D_11106610_DGM7640_GRGR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
